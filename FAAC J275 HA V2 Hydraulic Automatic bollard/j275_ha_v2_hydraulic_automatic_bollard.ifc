Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: j275_ha_v2_hydraulic_automatic_bollard.ifc
Time: 2016-06-16T13:00:45
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, J275 HA_V2 Hydraulic Automatic bollard
ePset_BIMobject_Lena - COLOR: Painted Steel; POSITION: Extended; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): J275 HA_V2 Hydraulic Automatic bollard; SKU (BO_prodsku): FAAC-J275-HA_V2; ManufacturName (BO_Manufac): FAAC; ProductFamily (BO_prodfam): AUTOMATION; ProductGroup (BO_prodgroup): TRAFFIC BOLLARD; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 5/9/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 450; Depth (BO_depth): 450; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/faac/product/FAAC-J275-HA_V2; ProductDataUrl (BO_prodaturl): bimobject.com/faac/product/FAAC-J275-HA_V2; InstallationInstructions (BO_montins): http://faac.international/products/traffic-bollards/controlli-accessi-dissuasori/#!/nav/FAAC_J275HA_BOLLARDS; ProductCertification (BO_prodcert): http://faac.international/products/traffic-bollards/controlli-accessi-dissuasori/#!/nav/FAAC_J275HA_BOLLARDS; TechnicalDescription (BO_techcert): http://faac.international/products/traffic-bollards/controlli-accessi-dissuasori/#!/nav/FAAC_J275HA_BOLLARDS; InstructionVideo (BO_youtube): https://vimeo.com/channels/faacproducts/80985663; MaterialMain (BO_mainmat): Steel; MaterialSecondary (BO_secmat): Stainless steel; BimObjectCategory (BO_bocat): Other; IfcClassification (BO_ifcclas): Object; Uniclass2015Code (BO_uniclass2015_code): Pr_20_76_08; Uniclass2015Description (BO_uniclass2015_desc): Bollards and impact protectors; OmniClassCode (BO_omniclass_code): 23-11 29 35; OmniClassDescription (BO_omniclass_name): Bollards; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
